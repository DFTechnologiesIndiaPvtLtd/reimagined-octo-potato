# Keil uVision project NET_12_uvision_K64F.uvprojx, settings and files
target NET_12_uvision_K64F (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.pdsc
  output: NET_12_uvision_K64F
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE -DTOOLCHAIN_ARM --restrict -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_SERIAL_FC=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DMBED_BUILD_TIMESTAMP=1484288340.98 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 --brief_diagnostics -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DFSL_RTOS_MBED --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DFEATURE_LWIP=1 -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; .; TARGET_CORTEX_M; TARGET_K64F; rtx; rtx/TARGET_CORTEX_M; .; EthernetInterface; lwip; lwip/include; lwip/include/netif; lwip/include/ipv4; lwip/include/ipv4/lwip; lwip/include/lwip; lwip/netif; lwip/netif/ppp; lwip-sys; lwip-sys/arch; TARGET_K64F; Socket; lwip-eth; lwip-eth/arch; lwip-eth/arch/TARGET_Freescale; .; storage_abstraction; .; TARGET_Freescale; TARGET_Freescale/TARGET_KSDK2_MCUS; TARGET_Freescale/TARGET_KSDK2_MCUS/api; TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F; TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM; TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device; TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD; TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group 
    ./: mbed_config.h Semaphore.h MemoryPool.h Mutex.h RtosTimer.h rtos_idle.h Queue.h Thread.h Mail.h rtos.h lp_ticker_api.h buffer.h spi_api.h serial_api.h analogin_api.h can_helper.h analogout_api.h rtc_api.h us_ticker_api.h i2c_api.h pwmout_api.h dma_api.h emac_api.h ethernet_api.h port_api.h gpio_irq_api.h gpio_api.h can_api.h trng_api.h sleep_api.h ticker_api.h pinmap.h mbed_pinmap_common.c mbed_gpio.c mbed_us_ticker_api.c mbed_lp_ticker_api.c mbed_ticker_api.c main.cpp
  group lwip
    lwip/: lwipopts.h
    lwip/include/ipv4/lwip/: autoip.h inet.h inet_chksum.h ip.h ip_frag.h icmp.h igmp.h ip_addr.h
    lwip/include/lwip/: sys.h snmp_msg.h snmp_structs.h sio.h udp.h mem.h netbuf.h netif.h timers.h init.h arch.h stats.h snmp_asn1.h sockets.h memp.h tcp_impl.h dhcp.h memp_std.h netdb.h netifapi.h err.h tcp.h def.h debug.h raw.h pbuf.h dns.h api.h snmp.h tcpip.h api_msg.h opt.h
  group Socket
    Socket/: UDPSocket.h TCPSocketServer.h Endpoint.h Socket.h TCPSocketConnection.h
  group EthernetInterface
    EthernetInterface/: eth_arch.h EthernetInterface.h
  group TARGET_MCU_K64F
    TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/: peripheral_clock_defines.h dma_reqs.h serial_api.c pwmout_api.c trng_api.c spi_api.c us_ticker.c storage_driver.c
  group TARGET_CORTEX_M
    TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
    rtx/TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
  group TARGET_Freescale
    lwip-eth/arch/TARGET_Freescale/: k64f_emac_config.h lwipopts_conf.h
    TARGET_Freescale/: mbed_rtx.h
  group drivers
    TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.h fsl_cmt.h fsl_rcm.h fsl_ewm.h fsl_flexcan.h fsl_lptmr.h fsl_pmc.h fsl_crc.h fsl_enet.h fsl_dspi_edma.h fsl_flash.h fsl_gpio.h fsl_sai_edma.h fsl_dmamux.h fsl_rnga.h fsl_pit.h fsl_port.h fsl_sai.h fsl_common.h fsl_i2c.h fsl_dspi.h fsl_sdhc.h fsl_uart.h fsl_dac.h fsl_llwu.h fsl_wdog.h fsl_pdb.h fsl_edma.h fsl_cmp.h fsl_ftm.h fsl_smc.h fsl_vref.h fsl_i2c_edma.h fsl_rtc.h fsl_flexbus.h fsl_uart_edma.h fsl_sim.h fsl_mpu.h fsl_clock.h fsl_ftm.c fsl_sai_edma.c fsl_dac.c fsl_crc.c fsl_clock.c fsl_vref.c fsl_flash.c fsl_sdhc.c fsl_mpu.c fsl_pmc.c fsl_uart.c fsl_uart_edma.c fsl_ewm.c fsl_enet.c fsl_common.c fsl_rcm.c fsl_llwu.c fsl_dmamux.c fsl_cmt.c fsl_flexbus.c fsl_rnga.c fsl_i2c_edma.c fsl_dspi.c fsl_cmp.c fsl_smc.c fsl_lptmr.c fsl_sai.c fsl_adc16.c fsl_sim.c fsl_wdog.c fsl_gpio.c fsl_pdb.c fsl_rtc.c fsl_i2c.c fsl_edma.c fsl_flexcan.c fsl_pit.c fsl_dspi_edma.c
  group storage_abstraction
    storage_abstraction/: Driver_Common.h Driver_Storage.h
  group ppp
    lwip/netif/ppp/: ppp.h pap.h chpms.h auth.h magic.h vj.h lcp.h md5.h pppdebug.h ipcp.h fsm.h randm.h chap.h
  group api
    TARGET_Freescale/TARGET_KSDK2_MCUS/api/: gpio_object.h PortNames.h dma_api_hal.h PeripheralPins.h objects.h analogout_api.c gpio_irq_api.c i2c_api.c port_api.c rtc_api.c pinmap.c dma_api.c sleep.c lp_ticker.c analogin_api.c gpio_api.c
  group arch
    lwip-sys/arch/: perf.h sys_arch.h cc.h
  group device
    TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/: MK64F12.h fsl_device_registers.h system_MK64F12.h MK64F12_features.h cmsis.h cmsis_nvic.h system_MK64F12.c cmsis_nvic.c
  group TARGET_FRDM
    TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: PeripheralNames.h fsl_phy.h PinNames.h crc.h device.h fsl_clock_config.h fsl_clock_config.c mbed_overrides.c crc.c fsl_phy.c PeripheralPins.c
  group TOOLCHAIN_ARM_STD
    TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/: startup_MK64F12.S sys.cpp
  group netif
    lwip/include/netif/: etharp.h ppp_oe.h slipif.h
