# Keil uVision project NET_12_uvision_LPC1768.uvprojx, settings and files
target NET_12_uvision_LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: NET_12_uvision_LPC1768
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTOOLCHAIN_ARM -DDEVICE_SEMIHOST=1 --restrict -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DARM_MATH_CM3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --multibyte_chars -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h --brief_diagnostics -DDEVICE_I2CSLAVE=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DFEATURE_LWIP=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1484285454.2 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -D__CORTEX_M3 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; .; TARGET_CORTEX_M; rtx; rtx/TARGET_CORTEX_M; .; EthernetInterface; lwip; lwip/include; lwip/include/netif; lwip/include/ipv4; lwip/include/ipv4/lwip; lwip/include/lwip; lwip/netif; lwip/netif/ppp; lwip-sys; lwip-sys/arch; Socket; lwip-eth; lwip-eth/arch; .; storage_abstraction; .; TARGET_NXP; TARGET_NXP/TARGET_LPC176X; TARGET_NXP/TARGET_LPC176X/device; TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD; TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h Semaphore.h MemoryPool.h Mutex.h RtosTimer.h rtos_idle.h Queue.h Thread.h Mail.h rtos.h lp_ticker_api.h buffer.h spi_api.h serial_api.h analogin_api.h can_helper.h analogout_api.h rtc_api.h us_ticker_api.h i2c_api.h pwmout_api.h dma_api.h emac_api.h ethernet_api.h port_api.h gpio_irq_api.h gpio_api.h can_api.h trng_api.h sleep_api.h ticker_api.h pinmap.h mbed_pinmap_common.c mbed_gpio.c mbed_us_ticker_api.c mbed_lp_ticker_api.c mbed_ticker_api.c main.cpp
  group lwip
    lwip/: lwipopts.h
    lwip/include/ipv4/lwip/: autoip.h inet.h inet_chksum.h ip.h ip_frag.h icmp.h igmp.h ip_addr.h
    lwip/include/lwip/: sys.h snmp_msg.h snmp_structs.h sio.h udp.h mem.h netbuf.h netif.h timers.h init.h arch.h stats.h snmp_asn1.h sockets.h memp.h tcp_impl.h dhcp.h memp_std.h netdb.h netifapi.h err.h tcp.h def.h debug.h raw.h pbuf.h dns.h api.h snmp.h tcpip.h api_msg.h opt.h
  group Socket
    Socket/: UDPSocket.h TCPSocketServer.h Endpoint.h Socket.h TCPSocketConnection.h
  group EthernetInterface
    EthernetInterface/: eth_arch.h EthernetInterface.h
  group TARGET_CORTEX_M
    TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
    rtx/TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
  group TARGET_LPC176X
    TARGET_NXP/TARGET_LPC176X/: gpio_object.h PeripheralNames.h PortNames.h objects.h analogout_api.c gpio_irq_api.c serial_api.c ethernet_api.c pwmout_api.c i2c_api.c port_api.c rtc_api.c pinmap.c can_api.c spi_api.c sleep.c us_ticker.c analogin_api.c gpio_api.c
  group TARGET_NXP
    TARGET_NXP/: mbed_rtx.h
  group TARGET_MBED_LPC1768
    TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: PinNames.h reserved_pins.h device.h
  group storage_abstraction
    storage_abstraction/: Driver_Common.h Driver_Storage.h
  group ppp
    lwip/netif/ppp/: ppp.h pap.h chpms.h auth.h magic.h vj.h lcp.h md5.h pppdebug.h ipcp.h fsm.h randm.h chap.h
  group device
    TARGET_NXP/TARGET_LPC176X/device/: LPC17xx.h system_LPC17xx.h cmsis.h cmsis_nvic.h system_LPC17xx.c cmsis_nvic.c
  group arch
    lwip-sys/arch/: perf.h sys_arch.h cc.h
  group TOOLCHAIN_ARM_STD
    TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/: startup_LPC17xx.S sys.cpp
  group netif
    lwip/include/netif/: etharp.h ppp_oe.h slipif.h
