# Keil uVision project NET_12_uvision_LPC4337.uvprojx, settings and files
target NET_12_uvision_LPC4337 (ARM-ADS)
  device: LPC4337 NXP
  pack: Keil.LPC4300_DFP.pdsc
  output: NET_12_uvision_LPC4337
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h --restrict -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_DEBUG_AWARENESS=1 -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --multibyte_chars -DDEVICE_INTERRUPTIN=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 -DMBED_BUILD_TIMESTAMP=1484299074.63 --brief_diagnostics -DTARGET_LPC43XX --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTOOLCHAIN_ARM --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_LPC4337 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -D__MBED_CMSIS_RTOS_CM
  c include: .; .; TARGET_LPC4337; TARGET_CORTEX_M; rtx; rtx/TARGET_CORTEX_M; .; EthernetInterface; TARGET_LPC4337; lwip; lwip/include; lwip/include/netif; lwip/include/ipv4; lwip/include/ipv4/lwip; lwip/include/lwip; lwip/netif; lwip/netif/ppp; lwip-sys; lwip-sys/arch; Socket; lwip-eth; lwip-eth/arch; lwip-eth/arch/TARGET_NXP; .; storage_abstraction; .; TARGET_NXP; TARGET_NXP/TARGET_LPC43XX; TARGET_NXP/TARGET_LPC43XX/TARGET_LPC4337; TARGET_NXP/TARGET_LPC43XX/device; TARGET_NXP/TARGET_LPC43XX/device/TOOLCHAIN_ARM_STD; TARGET_NXP/TARGET_LPC43XX/device/TOOLCHAIN_ARM_STD/TARGET_LPC4337;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__FPU_PRESENT=1,-DARM_MATH_CM4,-D__CORTEX_M4,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: TARGET_NXP/TARGET_LPC43XX/device/TOOLCHAIN_ARM_STD/TARGET_LPC4337/LPC4337.sct
  group 
    ./: mbed_config.h Semaphore.h MemoryPool.h Mutex.h RtosTimer.h rtos_idle.h Queue.h Thread.h Mail.h rtos.h lp_ticker_api.h buffer.h spi_api.h serial_api.h analogin_api.h can_helper.h analogout_api.h rtc_api.h us_ticker_api.h i2c_api.h pwmout_api.h dma_api.h emac_api.h ethernet_api.h port_api.h gpio_irq_api.h gpio_api.h can_api.h trng_api.h sleep_api.h ticker_api.h pinmap.h mbed_pinmap_common.c mbed_gpio.c mbed_us_ticker_api.c mbed_lp_ticker_api.c mbed_ticker_api.c main.cpp
  group TARGET_LPC43XX
    TARGET_NXP/TARGET_LPC43XX/: gpio_object.h PortNames.h objects.h analogout_api.c gpio_irq_api.c serial_api.c ethernet_api.c pwmout_api.c i2c_api.c port_api.c rtc_api.c pinmap.c spi_api.c sleep.c us_ticker.c analogin_api.c gpio_api.c
  group Socket
    Socket/: UDPSocket.h TCPSocketServer.h Endpoint.h Socket.h TCPSocketConnection.h
  group EthernetInterface
    EthernetInterface/: eth_arch.h EthernetInterface.h
  group TARGET_CORTEX_M
    TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
    rtx/TARGET_CORTEX_M/: RTX_Config.h rt_MemBox.h cmsis_os.h rt_Time.h rt_System.h rt_Task.h rt_HAL_CM.h rt_TypeDef.h rt_Event.h rt_Mutex.h rt_Robin.h rt_Memory.h rt_Mailbox.h rt_OsEventObserver.h rt_List.h rt_Timer.h rt_Semaphore.h RTX_CM_lib.h
  group TARGET_NXP
    lwip-eth/arch/TARGET_NXP/: lpc17xx_emac.h lpc_emac_config.h lwipopts_conf.h lpc_phy.h
    TARGET_NXP/: mbed_rtx.h
  group storage_abstraction
    storage_abstraction/: Driver_Common.h Driver_Storage.h
  group ppp
    lwip/netif/ppp/: ppp.h pap.h chpms.h auth.h magic.h vj.h lcp.h md5.h pppdebug.h ipcp.h fsm.h randm.h chap.h
  group device
    TARGET_NXP/TARGET_LPC43XX/device/: system_LPC43xx.h cmsis.h LPC43xx.h cmsis_nvic.h system_LPC43xx.c cmsis_nvic.c
  group lwip
    lwip/: lwipopts.h
    lwip/include/ipv4/lwip/: autoip.h inet.h inet_chksum.h ip.h ip_frag.h icmp.h igmp.h ip_addr.h
    lwip/include/lwip/: sys.h snmp_msg.h snmp_structs.h sio.h udp.h mem.h netbuf.h netif.h timers.h init.h arch.h stats.h snmp_asn1.h sockets.h memp.h tcp_impl.h dhcp.h memp_std.h netdb.h netifapi.h err.h tcp.h def.h debug.h raw.h pbuf.h dns.h api.h snmp.h tcpip.h api_msg.h opt.h
  group arch
    lwip-sys/arch/: perf.h sys_arch.h cc.h
  group TOOLCHAIN_ARM_STD
    TARGET_NXP/TARGET_LPC43XX/device/TOOLCHAIN_ARM_STD/: sys.cpp
  group TARGET_LPC4337
    TARGET_NXP/TARGET_LPC43XX/TARGET_LPC4337/: PeripheralNames.h PinNames.h device.h
    TARGET_NXP/TARGET_LPC43XX/device/TOOLCHAIN_ARM_STD/TARGET_LPC4337/: startup_LPC4337.S
  group netif
    lwip/include/netif/: etharp.h ppp_oe.h slipif.h
